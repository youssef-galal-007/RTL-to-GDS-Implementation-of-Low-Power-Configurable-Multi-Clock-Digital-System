

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI_dft[4] 
    ANTENNAPARTIALMETALAREA 0.319 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.53439 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 10.759 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.9432 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 252.151 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1219.41 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI_dft[4]
  PIN SI_dft[3] 
    ANTENNAPARTIALMETALAREA 2.15 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3415 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.541 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4146 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 26.754 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 128.879 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 572.207 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2766.1 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI_dft[3]
  PIN SI_dft[2] 
    ANTENNAPARTIALMETALAREA 1.299 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.24819 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.557 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.68157 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5132 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.6038 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.09235 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNAPARTIALMETALAREA 47.496 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 278.788 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 1117.21 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 6316.66 LAYER METAL7 ;
  END SI_dft[2]
  PIN SI_dft[1] 
    ANTENNAPARTIALMETALAREA 1.585 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.62385 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5531 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 50.2749 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 248.39 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI_dft[1]
  PIN SI_dft[0] 
    ANTENNAPARTIALMETALAREA 1.7 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.177 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 2.377 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6258 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 10.741 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 51.8566 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 427.204 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 2072.07 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 6.09568 LAYER VIA67 ;
  END SI_dft[0]
  PIN SO_dft[4] 
    ANTENNAPARTIALMETALAREA 2.913 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0115 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.35 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8759 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 7.402 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.796 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 82.204 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 397.076 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.17157 LAYER VIA56 ;
  END SO_dft[4]
  PIN SO_dft[3] 
    ANTENNAPARTIALMETALAREA 0.511 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.45791 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 9.142 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.1654 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2756 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 75.5395 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 367.778 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA45 ;
  END SO_dft[3]
  PIN SO_dft[2] 
    ANTENNAPARTIALMETALAREA 8.224 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.5574 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.222 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26022 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 7.894 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.1625 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 2.8858 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0688 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.6 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 39.132 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 229.858 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 282.546 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1573.54 LAYER METAL7 ;
  END SO_dft[2]
  PIN SO_dft[1] 
    ANTENNAPARTIALMETALAREA 2.257 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0486 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.04 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0048 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 28.781 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 138.629 LAYER METAL5 ;
  END SO_dft[1]
  PIN SO_dft[0] 
    ANTENNADIFFAREA 0.6 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 6.465 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.2891 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3588 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 280.595 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1353.61 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.07233 LAYER VIA34 ;
  END SO_dft[0]
  PIN i_Ref_Clk 
    ANTENNAPARTIALMETALAREA 0.291 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.39971 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.468 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.44348 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.386 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.04906 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.24383 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 6.12857 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END i_Ref_Clk
  PIN i_Uart_Clk 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.96 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.81 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.55 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8379 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.599647 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 3.03005 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END i_Uart_Clk
  PIN i_RST_n 
    ANTENNAPARTIALMETALAREA 0.893 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.29533 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.006 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.03126 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.35 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8759 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 22.608 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 108.937 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 511.989 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2473.64 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA56 ;
  END i_RST_n
  PIN i_RX_IN_sys 
    ANTENNAPARTIALMETALAREA 7.393 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.5603 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 37.086 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 178.576 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2886 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 150.333 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 721.509 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.698064 LAYER VIA34 ;
  END i_RX_IN_sys
  PIN SE_dft 
    ANTENNAPARTIALMETALAREA 1.585 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.62385 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 11.849 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 55.5326 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.205698 LAYER VIA23 ;
  END SE_dft
  PIN scan_clk_dft 
    ANTENNAPARTIALMETALAREA 0.583 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.80423 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.288 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.38768 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.55557 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.75522 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk_dft
  PIN scan_rst_n_dft 
    ANTENNAPARTIALMETALAREA 1.289 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.20009 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.145 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.88985 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.126 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.6585 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 16.235 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 78.2828 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 184.121 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 889.377 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA56 ;
  END scan_rst_n_dft
  PIN test_mode_dft 
    ANTENNAPARTIALMETALAREA 1.845 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.87445 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.432 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.27032 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 9.32721 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 48.2776 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.2434 LAYER VIA34 ;
  END test_mode_dft
  PIN o_Stop_Error_sys 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.775 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3478 LAYER METAL3 ;
  END o_Stop_Error_sys
  PIN o_Parity_Error_sys 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.113 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 68.0759 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3861 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 46.7525 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 228.336 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END o_Parity_Error_sys
  PIN o_TX_OUT_sys 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 7.745 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.2535 LAYER METAL3 ;
  END o_TX_OUT_sys
END SYS_TOP

END LIBRARY
